# Keil uVision project STM32-FD-CAN.uvprojx, settings and files
target STM32-CAN (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: CPUTYPE("Cortex-M3") CLOCK(10000000)
  output: STM32_FD_CAN +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: .\FWlib\inc;.\user;.\CM3;.\delay;.\new;..\TITR-STM32f103模板 未封库;.\ww;.\Device;.\aim
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Obj\STM32_FD_CAN.sct
  group User
    ./user/: main.c stm32f10x_it.c
  group FWLIB
    ./FWlib/SRC/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_can.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
  group Startup
    ./startup/: startup_stm32f10x_hd.s
  group CMSYS
    ./CM3/: core_cm3.c
  group Readme
    ./CM3/: system_stm32f10x.c
    ./user/: readme.txt
  group delay
    ./delay/: delay.c delay.h
  group bsp
    ./new/: bsp.c
  group device
    ./Device/: device.c
  group group
    ./Device/: sys.h
    ./sys/: sys.c
    ./: readme.txt
