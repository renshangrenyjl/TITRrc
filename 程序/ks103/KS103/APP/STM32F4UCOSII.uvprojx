# Keil uVision project STM32F4UCOSII.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4UCOSII +hex
  AfterMake: G:\KEIL5\Soft\MDK\ARM\ARMCC\bin\fromelf.exe
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F4XX,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,__FPU_PRESENT=1,ARM_MATH_CM4,__CC_ARM
  c include: ..\APP;..\BSP;..\CMSIS\Include;..\CMSIS\ST\STM32F4xx\Include;..\FWLIB\inc;..\uCOSII\Ports;..\uCOSII\Source;..\USER;..\Device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c stm32f4xx_it.c
  group BSP
    ../BSP/: bsp.c
  group CMSIS
    ../CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group DSP_Lib
    ../DSP_Lib/Source/BasicMathFunctions/: arm_abs_f32.c arm_add_f32.c arm_dot_prod_f32.c arm_mult_f32.c arm_negate_f32.c arm_offset_f32.c arm_scale_f32.c arm_sub_f32.c
    ../DSP_Lib/Source/CommonTables/: arm_common_tables.c
    ../DSP_Lib/Source/ComplexMathFunctions/: arm_cmplx_conj_f32.c arm_cmplx_dot_prod_f32.c arm_cmplx_mag_f32.c arm_cmplx_mag_squared_f32.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_real_f32.c
    ../DSP_Lib/Source/ControllerFunctions/: arm_pid_init_f32.c arm_pid_reset_f32.c arm_sin_cos_f32.c
    ../DSP_Lib/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
    ../DSP_Lib/Source/FilteringFunctions/: arm_biquad_cascade_df1_f32.c arm_biquad_cascade_df1_init_f32.c arm_biquad_cascade_df2T_f32.c arm_biquad_cascade_df2T_init_f32.c arm_conv_f32.c arm_conv_partial_f32.c arm_correlate_f32.c arm_fir_decimate_f32.c arm_fir_decimate_init_f32.c arm_fir_f32.c arm_fir_init_f32.c arm_fir_interpolate_f32.c arm_fir_interpolate_init_f32.c arm_fir_lattice_f32.c arm_fir_lattice_init_f32.c arm_fir_sparse_f32.c arm_fir_sparse_init_f32.c arm_iir_lattice_f32.c arm_iir_lattice_init_f32.c arm_lms_f32.c arm_lms_init_f32.c arm_lms_norm_f32.c arm_lms_norm_init_f32.c
    ../DSP_Lib/Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
    ../DSP_Lib/Source/StatisticsFunctions/: arm_max_f32.c arm_mean_f32.c arm_min_f32.c arm_power_f32.c arm_rms_f32.c arm_std_f32.c arm_var_f32.c
    ../DSP_Lib/Source/SupportFunctions/: arm_copy_f32.c arm_fill_f32.c arm_q7_to_float.c arm_q15_to_float.c arm_q31_to_float.c
    ../DSP_Lib/Source/TransformFunctions/: arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_rfft_f32.c arm_rfft_init_f32.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group startup
    ../startup/: startup_stm32f4xx.s
  group Device
    ../Device/: device.c
  group IIC
    ./: myiic.c delay.c
software components: CMSIS:CORE 5.0.0
